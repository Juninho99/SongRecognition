# Keil uVision project DSP_LiB.uvprojx, settings and files
target S6E2CC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: S6E2CCAJ0A Spansion
  pack: Keil.FM4_DFP.1.4.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFD0000,0x30000) IROM2(0x00406000,0xA000) IRAM2(0x20038000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DSP_LiB
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: .\drivers;.\RTE\Device\S6E2CCAJ0A
  memory RVCT4: ROM 0x0 size 0x300000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  group src
    ./src/: loop_intr.c
    ./: LOOKUP.h
  group drivers
    ./drivers/: audio.c delay.c gpio.c i2c.c i2s.c dstc.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Device:Startup 1.0.0
